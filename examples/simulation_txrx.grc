options:
  parameters:
    author: Teng-Hui Huang
    generate_options: qt_gui
    id: simulation_txrx
    output_language: python
    title: Wifi DSSS Simulation
  states: {}

blocks:
- name: rate
  id: variable_qtgui_chooser
  parameters:
    label: Rate
    labels: '["LONG1M", "LONG2M", "LONG5_5M", "LONG11M", "SHORT2M", "SHORT5_5M", "SHORT11M"]'
    num_opts: '0'
    options: '[0, 1, 2, 3, 4, 5, 6]'
    type: int
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: variable_qtgui_label_0
  id: variable_qtgui_label
  parameters:
    label: 'RX Expecting Preamble Type: '
    type: string
    value: '"Long Preamble" if rate < 4 else "Short Preamble"'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("TEST")
    period: '1000'
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: psdu_len
    type: byte
  states: {}
- name: pdu_random_pdu_0
  id: pdu_random_pdu
  parameters:
    length_modulo: '2'
    mask: '0xFF'
    maxsize: '200'
    minsize: '50'
  states: {}
- name: wifi_dsss_chip_sync_c_0
  id: wifi_dsss_chip_sync_c
  parameters:
    is_long_preamble: rate<4
    threshold: '0.8'
  states: {}
- name: wifi_dsss_ppdu_chip_mapper_bc_0
  id: wifi_dsss_ppdu_chip_mapper_bc
  parameters:
    lentag: '"psdu_len"'
  states: {}
- name: wifi_dsss_ppdu_prefixer_0
  id: wifi_dsss_ppdu_prefixer
  parameters:
    rate: rate
  states: {}

connections:
- [blocks_message_strobe_0, strobe, pdu_random_pdu_0, generate]
- [blocks_throttle2_0, '0', wifi_dsss_chip_sync_c_0, '0']
- [pdu_pdu_to_tagged_stream_0, '0', wifi_dsss_ppdu_chip_mapper_bc_0, '0']
- [pdu_random_pdu_0, pdus, wifi_dsss_ppdu_prefixer_0, psdu_in]
- [wifi_dsss_chip_sync_c_0, psdu_out, blocks_message_debug_0, print]
- [wifi_dsss_ppdu_chip_mapper_bc_0, '0', blocks_throttle2_0, '0']
- [wifi_dsss_ppdu_prefixer_0, ppdu_out, pdu_pdu_to_tagged_stream_0, pdus]

metadata:
  file_format: 1
  grc_version: 3.10.11.0
