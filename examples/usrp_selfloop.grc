<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>wifi_dsss_selfloop</value></param>
<param><key>author</key><value>Teng-Hui Huang</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>dev_id</value></param>
<param><key>value</key><value>"name=MyB210"</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>drate</value></param>
<param><key>value</key><value>0</value></param>
<param><key>label</key><value>Data Rate</value></param>
<param><key>labels</key><value>['Long-1M','Long-2M','Long-5.5M','Long-11M','Short-2M','Short-5.5M','Short-11M']</value></param>
<param><key>num_opts</key><value>0</value></param>
<param><key>options</key><value>[0, 1, 2,3,4,5,6]</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>fp_rx</value></param>
<param><key>block_id</key><value>pkt_monitor</value></param>
<param><key>function_name</key><value>get_rx</value></param>
<param><key>value</key><value>0</value></param>
<param><key>poll_rate</key><value>2</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>fp_tx</value></param>
<param><key>block_id</key><value>pkt_monitor</value></param>
<param><key>function_name</key><value>get_send</value></param>
<param><key>value</key><value>0</value></param>
<param><key>poll_rate</key><value>2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq</value></param>
<param><key>value</key><value>2.6e9</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>nfilts</value></param>
<param><key>value</key><value>32</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>preType</value></param>
<param><key>value</key><value>(int)(drate/4)==0</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>rx_gain</value></param>
<param><key>value</key><value>0.6</value></param>
<param><key>label</key><value>RX Gain</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>stop</key><value>1</value></param>
</block>
<block>
<key>variable_rrc_filter_taps</key>
<param><key>id</key><value>rx_rrc_taps</value></param>
<param><key>alpha</key><value>0.35</value></param>
<param><key>gain</key><value>nfilts</value></param>
<param><key>ntaps</key><value>11*sps*nfilts</value></param>
<param><key>samp_rate</key><value>nfilts*sps</value></param>
<param><key>sym_rate</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rx_subdev</value></param>
<param><key>value</key><value>"A:B"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>2e6</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>show_rx</value></param>
<param><key>value</key><value>fp_rx</value></param>
<param><key>formatter</key><value>""</value></param>
<param><key>label</key><value>Receiver packets</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>show_tx</value></param>
<param><key>value</key><value>fp_tx</value></param>
<param><key>label</key><value>Send Packets</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sps</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>tx_gain</value></param>
<param><key>value</key><value>0.8</value></param>
<param><key>label</key><value>TX Gain</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>stop</key><value>1</value></param>
</block>
<block>
<key>variable_rrc_filter_taps</key>
<param><key>id</key><value>tx_rrc_taps</value></param>
<param><key>alpha</key><value>0.35</value></param>
<param><key>gain</key><value>sps</value></param>
<param><key>ntaps</key><value>11*sps</value></param>
<param><key>samp_rate</key><value>sps</value></param>
<param><key>sym_rate</key><value>1.0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tx_subdev</value></param>
<param><key>value</key><value>"A:A"</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_0</value></param>
<param><key>msg</key><value>pmt.intern("TEST")</value></param>
<param><key>period</key><value>1000</value></param>
</block>
<block>
<key>blocks_pdu_to_tagged_stream</key>
<param><key>id</key><value>blocks_pdu_to_tagged_stream_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>"psdu_len"</value></param>
</block>
<block>
<key>blocks_random_pdu</key>
<param><key>id</key><value>blocks_random_pdu_0</value></param>
<param><key>mask</key><value>0xFF</value></param>
<param><key>length_modulo</key><value>2</value></param>
<param><key>maxsize</key><value>20</value></param>
<param><key>minsize</key><value>20</value></param>
</block>
<block>
<key>digital_pfb_clock_sync_xxx</key>
<param><key>id</key><value>digital_pfb_clock_sync_xxx_0</value></param>
<param><key>filter_size</key><value>nfilts</value></param>
<param><key>init_phase</key><value>nfilts/2</value></param>
<param><key>loop_bw</key><value>6.28/200</value></param>
<param><key>max_dev</key><value>1.5</value></param>
<param><key>osps</key><value>1</value></param>
<param><key>sps</key><value>sps</value></param>
<param><key>taps</key><value>rx_rrc_taps</value></param>
<param><key>type</key><value>ccf</value></param>
</block>
<block>
<key>gadget_burst_tagger_cc</key>
<param><key>id</key><value>gadget_burst_tagger_cc_0</value></param>
<param><key>mult</key><value>4</value></param>
<param><key>tagname</key><value>"psdu_len"</value></param>
</block>
<block>
<key>interp_fir_filter_xxx</key>
<param><key>id</key><value>interp_fir_filter_xxx_0</value></param>
<param><key>interp</key><value>sps</value></param>
<param><key>taps</key><value>tx_rrc_taps</value></param>
<param><key>type</key><value>ccf</value></param>
</block>
<block>
<key>gadget_packet_monitor</key>
<param><key>id</key><value>pkt_monitor</value></param>
<param><key>call</key><value>False</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
<param><key>center_freq0</key><value>freq</value></param>
<param><key>norm_gain0</key><value>True</value></param>
<param><key>gain0</key><value>tx_gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value>dev_id</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sd_spec0</key><value>tx_subdev</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
<param><key>len_tag_name</key><value></value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value>RX2</value></param>
<param><key>center_freq0</key><value>freq</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>True</value></param>
<param><key>gain0</key><value>rx_gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value>dev_id</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>sd_spec0</key><value>rx_subdev</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>wifi_dsss_chip_sync_c</key>
<param><key>id</key><value>wifi_dsss_chip_sync_c_0</value></param>
<param><key>preType</key><value>preType</value></param>
<param><key>threshold</key><value>8.0</value></param>
</block>
<block>
<key>wifi_dsss_ppdu_chip_mapper_bc</key>
<param><key>id</key><value>wifi_dsss_ppdu_chip_mapper_bc_0</value></param>
<param><key>lentag</key><value>"psdu_len"</value></param>
</block>
<block>
<key>wifi_dsss_ppdu_prefixer</key>
<param><key>id</key><value>wifi_dsss_ppdu_prefixer_0</value></param>
<param><key>rate</key><value>drate</value></param>
</block>
<connection><source_block_id>blocks_message_strobe_0</source_block_id><sink_block_id>blocks_random_pdu_0</sink_block_id><source_key>strobe</source_key><sink_key>generate</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0</source_block_id><sink_block_id>wifi_dsss_ppdu_chip_mapper_bc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_random_pdu_0</source_block_id><sink_block_id>pkt_monitor</sink_block_id><source_key>pdus</source_key><sink_key>send_in</sink_key></connection>
<connection><source_block_id>blocks_random_pdu_0</source_block_id><sink_block_id>wifi_dsss_ppdu_prefixer_0</sink_block_id><source_key>pdus</source_key><sink_key>psdu_in</sink_key></connection>
<connection><source_block_id>digital_pfb_clock_sync_xxx_0</source_block_id><sink_block_id>wifi_dsss_chip_sync_c_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gadget_burst_tagger_cc_0</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>interp_fir_filter_xxx_0</source_block_id><sink_block_id>gadget_burst_tagger_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>digital_pfb_clock_sync_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>wifi_dsss_chip_sync_c_0</source_block_id><sink_block_id>pkt_monitor</sink_block_id><source_key>psdu_out</source_key><sink_key>rx_in</sink_key></connection>
<connection><source_block_id>wifi_dsss_ppdu_chip_mapper_bc_0</source_block_id><sink_block_id>interp_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>wifi_dsss_ppdu_prefixer_0</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_0</sink_block_id><source_key>ppdu_out</source_key><sink_key>pdus</sink_key></connection>
</flow_graph>
