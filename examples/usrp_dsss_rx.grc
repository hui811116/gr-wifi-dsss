<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>usrp_dsss_rx</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>fp_rx</value></param>
<param><key>block_id</key><value>pkt_monitor</value></param>
<param><key>function_name</key><value>get_rx</value></param>
<param><key>value</key><value>0</value></param>
<param><key>poll_rate</key><value>2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq_data</value></param>
<param><key>value</key><value>2.4e9</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>nfilts</value></param>
<param><key>value</key><value>32</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>preType</value></param>
<param><key>value</key><value>True</value></param>
<param><key>label0</key><value>"Short Preamble"</value></param>
<param><key>label1</key><value>"Long Preamble"</value></param>
<param><key>label</key><value>Preamble Type</value></param>
<param><key>num_opts</key><value>2</value></param>
<param><key>option0</key><value>False</value></param>
<param><key>option1</key><value>True</value></param>
<param><key>type</key><value>raw</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rx_dev</value></param>
<param><key>value</key><value>"name=MyB210"</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>rx_gain</value></param>
<param><key>value</key><value>0.6</value></param>
<param><key>label</key><value>RX Gain</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>stop</key><value>1</value></param>
</block>
<block>
<key>variable_rrc_filter_taps</key>
<param><key>id</key><value>rx_rrc_taps</value></param>
<param><key>alpha</key><value>0.35</value></param>
<param><key>gain</key><value>nfilts</value></param>
<param><key>ntaps</key><value>11*sps*nfilts</value></param>
<param><key>samp_rate</key><value>nfilts*sps</value></param>
<param><key>sym_rate</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rx_subdev</value></param>
<param><key>value</key><value>"A:B"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>2e6</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>show_rx</value></param>
<param><key>value</key><value>fp_rx</value></param>
<param><key>formatter</key><value>""</value></param>
<param><key>label</key><value>Receiver packets</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sps</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>digital_pfb_clock_sync_xxx</key>
<param><key>id</key><value>digital_pfb_clock_sync_xxx_0</value></param>
<param><key>filter_size</key><value>nfilts</value></param>
<param><key>init_phase</key><value>nfilts/2</value></param>
<param><key>loop_bw</key><value>6.28/200</value></param>
<param><key>max_dev</key><value>1.5</value></param>
<param><key>osps</key><value>1</value></param>
<param><key>sps</key><value>sps</value></param>
<param><key>taps</key><value>rx_rrc_taps</value></param>
<param><key>type</key><value>ccf</value></param>
</block>
<block>
<key>gadget_packet_monitor</key>
<param><key>id</key><value>pkt_monitor</value></param>
<param><key>call</key><value>False</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value>RX2</value></param>
<param><key>center_freq0</key><value>freq_data</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>True</value></param>
<param><key>gain0</key><value>rx_gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value>rx_dev</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>sd_spec0</key><value>rx_subdev</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>wifi_dsss_chip_sync_c</key>
<param><key>id</key><value>wifi_dsss_chip_sync_c_0</value></param>
<param><key>preType</key><value>preType</value></param>
<param><key>threshold</key><value>8.0</value></param>
</block>
<connection><source_block_id>digital_pfb_clock_sync_xxx_0</source_block_id><sink_block_id>wifi_dsss_chip_sync_c_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>digital_pfb_clock_sync_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>wifi_dsss_chip_sync_c_0</source_block_id><sink_block_id>pkt_monitor</sink_block_id><source_key>psdu_out</source_key><sink_key>rx_in</sink_key></connection>
</flow_graph>
